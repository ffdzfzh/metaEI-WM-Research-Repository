options:
  parameters:
    author: fzh
    generate_options: qt_gui
    id: QPSK2
    output_language: python
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: cc_decoder
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_encoder
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: header_format_default
  id: variable_header_format_default
  parameters:
    access_code: '11011011001100001111011100000011'
    bps: '1'
    threshold: '3'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: str(__import__('pathlib').Path(__file__).resolve().parents[1] / 'media' / 'videos' / 'trans.ts')
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"frame"'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '512'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: center_freq
    type: intx
    value: '3500000000'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {}
- name: delay
  id: parameter
  parameters:
    label: delay
    type: eng_float
    value: '50'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11011011001100001111011100000011'
    tagname: frame
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"frame"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_1_0
  id: digital_protocol_formatter_bb
  parameters:
    format: header_format_default
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\r\nfrom gnuradio import gr\r\nimport math\r\nimport time\r\nimport datetime\nimport os\nfrom pathlib import Path\n\r\n\r\nclass monitor_metrics(gr.sync_block):\r\n    \"\"\"Monitor QPSK power, BER, capacity, and constellation samples.\"\"\"\n\r\n    def __init__(self, window_size=1000, symbol_rate=1500000):\r\n        gr.sync_block.__init__(self,\r\n                               name='QPSK Metrics Monitor',\r\n                               in_sig=[np.complex64],\r\n                               out_sig=[np.float32, np.float32]  # 0: Log_BER, 1: Cap_Mbps\r\n                               )\r\n        self.window_size = window_size\r\n        self.symbol_rate = symbol_rate\r\n\r\n        self.current_ber = 1.0\r\n        self.current_cap = 0.0\r\n        self.current_pwr = 0.0\r\n\r\n        self.last_save_time = time.time()\n        timestamp = datetime.datetime.now().strftime(\"%Y%m%d_%H%M%S\")\n        output_dir = Path(__file__).resolve().parents[3] / \"outputs\" / \"usrp\" / \"constellation\"\n        output_dir.mkdir(parents=True, exist_ok=True)\n        self.filename = str(output_dir / f\"data_{timestamp}.csv\")\n\r\n        try:\r\n            with open(self.filename, 'w') as f:\r\n                f.write(\"Timestamp,Log10_BER,Capacity_Mbps,Rx_Power_dB\\n\")\r\n            print(f\"[INFO] Data will be saved to: {os.path.abspath(self.filename)}\")\r\n        except Exception as e:\r\n            print(f\"[ERROR] Cannot create file: {e}\")\r\n\r\n        self.constellation_buffer = np.zeros(2048, dtype=np.complex64)\r\n        self.buffer_idx = 0\r\n        self.buffer_full = False\r\n\r\n    def work(self, input_items, output_items):\r\n        in0 = input_items[0]\r\n        n_input = len(in0)\r\n\r\n        if n_input == 0:\r\n            return 0\r\n\r\n        if n_input >= len(self.constellation_buffer):\r\n            self.constellation_buffer[:] = in0[-len(self.constellation_buffer):]\r\n            self.buffer_idx = 0\r\n            self.buffer_full = True\r\n        else:\r\n            space_left = len(self.constellation_buffer) - self.buffer_idx\r\n            if n_input <= space_left:\r\n                self.constellation_buffer[self.buffer_idx:self.buffer_idx + n_input] = in0\r\n                self.buffer_idx += n_input\r\n            else:\r\n                self.constellation_buffer[self.buffer_idx:] = in0[:space_left]\r\n                self.constellation_buffer[:n_input - space_left] = in0[space_left:]\r\n                self.buffer_idx = n_input - space_left\r\n                self.buffer_full = True\r\n\r\n        rx_power = np.mean(np.abs(in0) ** 2)\r\n        if rx_power < 1e-12: rx_power = 1e-12\r\n\r\n        self.current_pwr = 10 * math.log10(rx_power)\r\n\r\n\r\n        norm_factor = 1.0 / math.sqrt(rx_power)\r\n        in0_norm = in0 * norm_factor\r\n\r\n        decisions = np.sign(in0_norm.real) * 0.7071 + 1j * (np.sign(in0_norm.imag) * 0.7071)\r\n\r\n        error_vector = in0_norm - decisions\r\n        mean_err_power = np.mean(np.abs(error_vector) ** 2)\r\n\r\n        if mean_err_power < 1e-12: mean_err_power = 1e-12\r\n\r\n        snr_lin = 1.0 / mean_err_power\r\n\r\n        # Capacity (Mbps) = Symbol_Rate * log2(1 + SNR) / 1e6\r\n        cap_bits_per_sym = math.log2(1 + snr_lin)\r\n        cap_mbps = (cap_bits_per_sym * self.symbol_rate) / 1e6\r\n\r\n        eb_n0 = snr_lin / 2.0\r\n        ber_linear = 0.5 * math.erfc(math.sqrt(eb_n0))\r\n        if ber_linear < 1e-9: ber_linear = 1e-9\r\n        ber_log = math.log10(ber_linear)\r\n\r\n        self.current_ber = ber_linear\r\n        self.current_cap = cap_mbps\r\n\r\n        now = time.time()\r\n        if now - self.last_save_time >= 1.0:\r\n            try:\r\n                with open(self.filename, 'a') as f:\r\n                    f.write(f\"{now},{ber_log:.4f},{cap_mbps:.4f},{self.current_pwr:.2f}\\n\")\r\n                self.last_save_time = now\r\n            except Exception:\r\n                pass\r\n\r\n        output_items[0][:] = ber_log\r\n        output_items[1][:] = cap_mbps\r\n\r\n        return n_input\r\n\r\n    def __del__(self):\r\n        \"\"\"Append buffered constellation samples when the flow graph stops.\"\"\"\n        try:\r\n            if not self.buffer_full:\r\n                data_to_save = self.constellation_buffer[:self.buffer_idx]\r\n            else:\r\n                data_to_save = np.concatenate((self.constellation_buffer[self.buffer_idx:],\r\n                                               self.constellation_buffer[:self.buffer_idx]))\r\n\r\n            with open(self.filename, 'a') as f:\r\n                f.write(\"\\n---CONST_DATA_START---\\n\")\r\n                f.write(\"I,Q\\n\")\r\n                for c in data_to_save:\r\n                    f.write(f\"{c.real:.6f},{c.imag:.6f}\\n\")\r\n            print(\"[INFO] Constellation data appended to CSV.\")\r\n        except Exception as e:\r\n            print(f\"[ERROR] Failed to save final constellation: {e}\")\r\n"
    symbol_rate: samp_rate /2
    window_size: '1000'
  states: {}
- name: eq_gain
  id: parameter
  parameters:
    label: eq_gain
    type: eng_float
    value: '0.01'
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    label: freq_offset
    type: eng_float
    value: '0'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1024'
    port: '2345'
    send_eof: 'False'
    type: byte
  states: {}
- name: noise_volt
  id: parameter
  parameters:
    label: noise_volt
    type: eng_float
    value: '0.1'
  states: {}
- name: phase_bw
  id: parameter
  parameters:
    label: phase_bw
    type: eng_float
    value: 6.28/100
  states: {}
- name: qtgui_const_sink_x_3
  id: qtgui_const_sink_x
  parameters:
    name: '"Received Constellation"'
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Transmission Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"Real-time BER"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Log(BER)
    ymax: '0'
    ymin: '-8'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"Channel Capacity"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Mbps
    ymax: '20'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    name: '"Received Time-Domain Waveform"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Received Spectral Waterfall Diagram"'
    type: complex
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: min-0
    type: intx
    value: '10'
  states: {}
- name: time_offset
  id: parameter
  parameters:
    label: Timing_Offset
    type: eng_float
    value: '1'
  states: {}
- name: timing_loop_bw
  id: parameter
  parameters:
    label: timing_loop_bw
    type: eng_float
    value: 6.28/100
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: max-0
    type: intx
    value: '10'
  states: {}
- name: uri
  id: parameter
  parameters:
    label: ip:192.168.1.10
    type: str
    value: ip:192.168.1.10
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Tx
  states: {}

connections:
- [analog_agc_xx_0, '0', epy_block_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_3, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', analog_agc_xx_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_crc32_bb_0_0, '0', digital_protocol_formatter_bb_1_0, '0']
- [digital_crc32_bb_0_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_crc32_bb_0_0_0, '0', network_udp_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_protocol_formatter_bb_1_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '1', qtgui_time_sink_x_1, '0']
- [virtual_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']

metadata:
  file_format: 1
